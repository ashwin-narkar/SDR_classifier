options:
  parameters:
    author: ashwin
    generate_options: qt_gui
    id: bluetooth_rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: freq_label
    start: 2402e6
    step: 1e6
    stop: 2480e6
    value: 2426e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1e-4'
    threshold: '-80'
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1e-4'
    threshold: '-80'
  states: {}
- name: analog_simple_squelch_cc_0_1
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1e-4'
    threshold: '-80'
  states: {}
- name: analog_simple_squelch_cc_0_2
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1e-4'
    threshold: '-80'
  states: {}
- name: analog_simple_squelch_cc_0_3
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1e-4'
    threshold: '-80'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '16'
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_LSB_FIRST
    type: byte
  states: {state: disabled}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '4'
    sensitivity: '1.0'
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -1e6, 1e6/2, 1e5)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq-1e6
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -1e6, 1e6/2, 1e5)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq-2e6
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -1e6, 1e6/2, 1e5)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq+1e6
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -1e6, 1e6/2, 1e5)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_4
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq+2e6
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -1e6, 1e6/2, 1e5)
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_2
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_3
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/2
    fc: '0'
    fftsize: '1024'
    name: '"Post Squelch"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/2
    fc: '0'
    fftsize: '1024'
    name: '"Post Squelch"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/2
    fc: '0'
    fftsize: '1024'
    name: '"Post Squelch"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/2
    fc: '0'
    fftsize: '1024'
    name: '"Post Squelch"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/2
    fc: '0'
    fftsize: '1024'
    name: '"Post Squelch"'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"Unpacked"'
    type: byte
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"Packed"'
    type: byte
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate/2
    center_freq0: freq
    dev_addr: ''
    dev_args: '""'
    gain0: '20'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', qtgui_const_sink_x_0, '0']
- [analog_simple_squelch_cc_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_simple_squelch_cc_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [analog_simple_squelch_cc_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [analog_simple_squelch_cc_0_1, '0', qtgui_const_sink_x_0_1, '0']
- [analog_simple_squelch_cc_0_1, '0', qtgui_freq_sink_x_0_0_1, '0']
- [analog_simple_squelch_cc_0_2, '0', qtgui_const_sink_x_0_2, '0']
- [analog_simple_squelch_cc_0_2, '0', qtgui_freq_sink_x_0_0_2, '0']
- [analog_simple_squelch_cc_0_3, '0', qtgui_const_sink_x_0_3, '0']
- [analog_simple_squelch_cc_0_3, '0', qtgui_freq_sink_x_0_0_3, '0']
- [blocks_stream_to_tagged_stream_0, '0', qtgui_number_sink_1, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_gfsk_demod_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_gfsk_demod_0, '0', qtgui_number_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', analog_simple_squelch_cc_0_1, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', analog_simple_squelch_cc_0_3, '0']
- [freq_xlating_fir_filter_xxx_0_3, '0', analog_simple_squelch_cc_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_4, '0', analog_simple_squelch_cc_0_2, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_3, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0_4, '0']

metadata:
  file_format: 1
