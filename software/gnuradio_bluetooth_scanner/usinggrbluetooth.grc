options:
  parameters:
    author: ashwin
    generate_options: no_gui
    id: usinggrbluetooth
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 2.426e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 10e6
  states: {}
- name: bluetooth_multi_sniffer_0
  id: bluetooth_multi_sniffer
  parameters:
    center_freq: freq
    sample_rate: samp_rate
    squelch_threshold: '-70'
    tun: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -0.5e6, .5e6, 1e5)
    type: ccc
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '0.7'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [uhd_usrp_source_0, '0', bluetooth_multi_sniffer_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
