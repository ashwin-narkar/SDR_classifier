options:
  parameters:
    author: ashwin
    generate_options: qt_gui
    id: onnx_modelclassifier
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: threshold_noise_filter
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '2'
    stop: '100'
    value: '1'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '5e-4'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    vlen: '128'
  states: {}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters:
    vlen: '128'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_correctiq_0
  id: blocks_correctiq
  parameters: {}
  states: {}
- name: blocks_correctiq_0_0
  id: blocks_correctiq
  parameters: {}
  states: {state: disabled}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '128'
    max_iter: '4000'
    scale: 1/128
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: float
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: complex
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_vector_to_stream_1_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_1_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_2_0_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '15'
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_2_0_0_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '15'
    type: float
  states: {}
- name: blocks_vector_to_stream_2_0_0_1_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '15'
    type: float
  states: {state: disabled}
- name: dnn_dnn_onnx_sync_0
  id: dnn_dnn_onnx_sync
  parameters:
    input_size: '256'
    onnx_batch_size: '1'
    onnx_model_file: /home/ashwin/Documents/Capstone/data/fft_model.onnx
    onnx_runtime_device: GPU
    output_size: '15'
  states: {}
- name: dnn_dnn_onnx_sync_0_0
  id: dnn_dnn_onnx_sync
  parameters:
    input_size: '256'
    onnx_batch_size: '1'
    onnx_model_file: /home/ashwin/Documents/Capstone/data/fft_model.onnx
    onnx_runtime_device: GPU
    output_size: '15'
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.vlen = vlen

          def work(self, input_items, output_items):
              inp = np.asarray(input_items[0])
              
              # print(len(input_items[0]))
              # print(len(input_items[0][0]))
              # print(inp.shape)
                  # self.firstrun = False
              mean = np.mean(inp)
              std_dev = np.std(inp)

              output_items[0][:] = input_items[0] - mean
              output_items[0][:] = output_items[0] / std_dev
              return len(output_items[0])
    vlen: '128'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.firstrun = True
              self.vlen = vlen

          def work(self, input_items, output_items):
              inp = np.asarray(input_items[0])
              
              # print(len(input_items[0]))
              # print(len(input_items[0][0]))
              # print(inp.shape)
                  # self.firstrun = False
              mean = np.mean(inp)
              std_dev = np.std(inp)

              output_items[0][:] = input_items[0] - mean
              output_items[0][:] = output_items[0] / std_dev
              return len(output_items[0])
    vlen: '128'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.firstrun = True
              self.vlen = vlen

          def work(self, input_items, output_items):
              inp = np.asarray(input_items[0])
              
              # print(len(input_items[0]))
              # print(len(input_items[0][0]))
              # print(inp.shape)
                  # self.firstrun = False
              mean = np.mean(inp)
              std_dev = np.std(inp)

              output_items[0][:] = input_items[0] - mean
              output_items[0][:] = output_items[0] / std_dev
              return len(output_items[0])
    vlen: '128'
  states: {state: disabled}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.vlen = vlen

          def work(self, input_items, output_items):
              inp = np.asarray(input_items[0])
              
              # print(len(input_items[0]))
              # print(len(input_items[0][0]))
              # print(inp.shape)
                  # self.firstrun = False
              mean = np.mean(inp)
              std_dev = np.std(inp)

              output_items[0][:] = input_items[0] - mean
              output_items[0][:] = output_items[0] / std_dev
              return len(output_items[0])
    vlen: '128'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=15, thresh = 1):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[(np.float32,vlen),(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.thres = thresh

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              # input_items[i] is ith input vector
              # input_items[i][0] is the actual vector itself with 15 elements to address

              for i in range(15):
                  if (1/self.thres) <= input_items[0][0][i] / input_items[1][0][i] <= self.thres:
                      output_items[0][0][i] = max(input_items[0][0][i],input_items[1][0][i])
                  else:
                      output_items[0][0][i] = 0

              return len(output_items[0])
    thresh: threshold_noise_filter
    vlen: '15'
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '128'
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(128)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '128'
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(128)
  states: {state: disabled}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 2426.5e6
    decim: '2'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2), samp_rate/(2), 1e5)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 2426.5e6
    decim: '2'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2), samp_rate/(2), 1e5)
    type: ccc
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/2
    fc: 2.4265e9
    fftsize: '128'
    name: '"Raw Input Signal"'
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0_0_0_0_1
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Classification Noise Filter"'
    ncols: '15'
    nrows: '256'
    samp_rate: 10e6
    type: float
    x_end_value: '15'
    x_label: '"Class"'
    x_start_value: '0'
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_0_0_0_1_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Classification USRP 3186907"'
    ncols: '15'
    nrows: '256'
    samp_rate: 10e6
    type: float
    x_end_value: '15'
    x_label: '"Class"'
    x_start_value: '0'
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_0_0_0_0_1_1
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Classification USRP 2"'
    ncols: '15'
    nrows: '256'
    samp_rate: 10e6
    type: float
    x_end_value: '15'
    x_label: '"Class"'
    x_start_value: '0'
    zmin: '0'
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 2426.5e6
    dev_addr: '"serial=3186907"'
    gain0: '0.9'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: 2426.5e6
    dev_addr: '"serial=31764D0"'
    gain0: '0.9'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}

connections:
- [analog_noise_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_float_0, '0', epy_block_0, '0']
- [blocks_complex_to_float_0, '1', epy_block_0_0, '0']
- [blocks_complex_to_float_0_0, '0', epy_block_0_1, '0']
- [blocks_complex_to_float_0_0, '1', epy_block_0_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_correctiq_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_correctiq_0_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_interleave_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_interleave_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_stream_to_vector_0, '0', dnn_dnn_onnx_sync_0, '0']
- [blocks_stream_to_vector_0_0, '0', dnn_dnn_onnx_sync_0_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_stream_to_vector_1_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_interleave_0, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_interleave_0, '1']
- [blocks_vector_to_stream_1_0_0, '0', blocks_interleave_0_0, '1']
- [blocks_vector_to_stream_1_1, '0', blocks_interleave_0_0, '0']
- [blocks_vector_to_stream_2_0_0_1, '0', qtgui_time_raster_sink_x_0_0_0_0_1, '0']
- [blocks_vector_to_stream_2_0_0_1_0, '0', qtgui_time_raster_sink_x_0_0_0_0_1_0, '0']
- [blocks_vector_to_stream_2_0_0_1_1, '0', qtgui_time_raster_sink_x_0_0_0_0_1_1, '0']
- [dnn_dnn_onnx_sync_0, '0', blocks_vector_to_stream_2_0_0_1_0, '0']
- [dnn_dnn_onnx_sync_0, '0', epy_block_2, '0']
- [dnn_dnn_onnx_sync_0_0, '0', blocks_vector_to_stream_2_0_0_1_1, '0']
- [dnn_dnn_onnx_sync_0_0, '0', epy_block_2, '1']
- [epy_block_0, '0', blocks_vector_to_stream_1, '0']
- [epy_block_0_0, '0', blocks_vector_to_stream_1_0, '0']
- [epy_block_0_0_0, '0', blocks_vector_to_stream_1_0_0, '0']
- [epy_block_0_1, '0', blocks_vector_to_stream_1_1, '0']
- [epy_block_2, '0', blocks_vector_to_stream_2_0_0_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_float_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_float_0_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_stream_to_vector_1, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [uhd_usrp_source_0, '0', blocks_correctiq_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_correctiq_0_0, '0']

metadata:
  file_format: 1
