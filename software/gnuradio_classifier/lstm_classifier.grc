options:
  parameters:
    author: ashwin
    generate_options: qt_gui
    id: lstm_modelclassifier
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: threshold
  id: variable_function_probe
  parameters:
    block_id: avg_energy
    function_name: level
    poll_rate: '10'
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: threshold
    type: float
  states: {}
- name: avg_energy
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    vlen: '128'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '20'
    max_iter: '4000'
    scale: 1/20
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
    vlen: '15'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: complex
  states: {}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '15'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '-4'
    init: '0'
    low: '-5'
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_vector_to_stream_2_0_0_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '15'
    type: float
  states: {}
- name: dnn_dnn_onnx_sync_0
  id: dnn_dnn_onnx_sync
  parameters:
    input_size: '256'
    onnx_batch_size: '1'
    onnx_model_file: /home/ashwin/Documents/Capstone/data/lstm_iq.onnx
    onnx_runtime_device: CPU
    output_size: '15'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.vlen = vlen

          def work(self, input_items, output_items):
              inp = np.asarray(input_items[0])
              
              # print(len(input_items[0]))
              # print(len(input_items[0][0]))
              # print(inp.shape)
                  # self.firstrun = False
              mean = np.mean(inp)
              std_dev = np.std(inp)

              output_items[0][:] = input_items[0] - mean
              output_items[0][:] = output_items[0] / std_dev
              return len(output_items[0])
    vlen: '128'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.firstrun = True
              self.vlen = vlen

          def work(self, input_items, output_items):
              inp = np.asarray(input_items[0])
              
              # print(len(input_items[0]))
              # print(len(input_items[0][0]))
              # print(inp.shape)
                  # self.firstrun = False
              mean = np.mean(inp)
              std_dev = np.std(inp)

              output_items[0][:] = input_items[0] - mean
              output_items[0][:] = output_items[0] / std_dev
              return len(output_items[0])
    vlen: '128'
  states: {}
- name: epy_module_0
  id: epy_module
  parameters:
    source_code: '# this module will be imported in the into your flowgraph'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 2426.5e6
    decim: '2'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2), samp_rate/(2), 1e5)
    type: ccc
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/2
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_raster_sink_x_0_0_0_0_1_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Classification USRP 3186907"'
    ncols: '15'
    nrows: '256'
    samp_rate: 10e6
    type: float
    zmin: '0'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: TX/RX
    center_freq0: 2.4265e9
    dc_offs_enb0: '""'
    dev_addr: '"serial=3186907"'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'True'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_stream_to_vector_2, '0']
- [blocks_complex_to_float_0, '0', epy_block_0, '0']
- [blocks_complex_to_float_0, '1', epy_block_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_interleave_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_multiply_xx_0, '0', blocks_vector_to_stream_2_0_0_1_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_threshold_ff_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink_1, '0']
- [blocks_stream_to_vector_0, '0', dnn_dnn_onnx_sync_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_complex_to_float_0, '0']
- [blocks_stream_to_vector_2, '0', blocks_multiply_xx_0, '1']
- [blocks_threshold_ff_0, '0', avg_energy, '0']
- [blocks_vector_to_stream_1, '0', blocks_interleave_0, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_interleave_0, '1']
- [blocks_vector_to_stream_2_0_0_1_0, '0', qtgui_time_raster_sink_x_0_0_0_0_1_0, '0']
- [dnn_dnn_onnx_sync_0, '0', blocks_multiply_xx_0, '0']
- [epy_block_0, '0', blocks_vector_to_stream_1, '0']
- [epy_block_0_0, '0', blocks_vector_to_stream_1_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_moving_average_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_stream_to_vector_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
