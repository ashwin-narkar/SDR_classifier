options:
  parameters:
    author: ashwin
    generate_options: qt_gui
    id: classify_from_file
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: threshold
  id: variable_function_probe
  parameters:
    block_id: probe_avg_energy_0
    function_name: level
    poll_rate: samp_rate/4
    value: '0'
  states: {state: disabled}
- name: blocks_complex_to_float_0_0
  id: blocks_complex_to_float
  parameters:
    vlen: '128'
  states: {}
- name: blocks_complex_to_mag_squared_1_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '128'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ashwin/Documents/Capstone/software/gnuradio_wifi_scanner/rawwifisignal.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_interleave_0_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: (threshold,threshold,threshold,threshold,threshold,threshold,threshold,threshold,threshold,threshold,threshold,threshold,threshold,threshold,threshold)
    type: float
    vlen: '15'
  states: {state: disabled}
- name: blocks_nlog10_ff_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
    vlen: '128'
  states: {state: disabled}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: float
  states: {}
- name: blocks_stream_to_vector_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_vector_to_stream_1_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_vector_to_stream_2_0_0_1_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '15'
    type: float
  states: {state: disabled}
- name: blocks_vector_to_stream_2_0_0_1_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '15'
    type: float
  states: {}
- name: dnn_dnn_onnx_sync_0_0
  id: dnn_dnn_onnx_sync
  parameters:
    input_size: '256'
    onnx_batch_size: '1'
    onnx_model_file: /home/ashwin/Documents/Capstone/data/lstm_iq.onnx
    onnx_runtime_device: CPU
    output_size: '15'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.firstrun = True
              self.vlen = vlen

          def work(self, input_items, output_items):
              inp = np.asarray(input_items[0])
              
              # print(len(input_items[0]))
              # print(len(input_items[0][0]))
              # print(inp.shape)
                  # self.firstrun = False
              mean = np.mean(inp)
              std_dev = np.std(inp)

              output_items[0][:] = input_items[0] - mean
              output_items[0][:] = output_items[0] / std_dev
              return len(output_items[0])
    vlen: '128'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.vlen = vlen

          def work(self, input_items, output_items):
              inp = np.asarray(input_items[0])
              
              # print(len(input_items[0]))
              # print(len(input_items[0][0]))
              # print(inp.shape)
                  # self.firstrun = False
              mean = np.mean(inp)
              std_dev = np.std(inp)

              output_items[0][:] = input_items[0] - mean
              output_items[0][:] = output_items[0] / std_dev
              return len(output_items[0])
    vlen: '128'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=128, threshold=-40.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Vector Average',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.vlen = vlen
              self.thresh = threshold

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              inp = np.asarray(input_items[0])
              if (np.mean(inp) >= self.thresh):
                  output_items[0][:] = 1
              else:
                  output_items[0][:] = 0
              return len(output_items[0])
    threshold: '-40.0'
    vlen: '128'
  states: {state: disabled}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '128'
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(128)
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 2426.5e6
    decim: '2'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2), samp_rate/(2), 1e5)
    type: ccc
  states: {}
- name: probe_avg_energy_0
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_raster_sink_x_0_0_0_0_1_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Classification USRP 3186907"'
    ncols: '15'
    nrows: '256'
    samp_rate: 10e6
    type: float
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_0_0_0_1_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Classification USRP 3186907"'
    ncols: '15'
    nrows: '256'
    samp_rate: 10e6
    type: float
    zmin: '0'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '128'
    x_start: '0'
    x_step: '1.0'
  states: {state: disabled}

connections:
- [blocks_complex_to_float_0_0, '0', epy_block_0_1, '0']
- [blocks_complex_to_float_0_0, '1', epy_block_0_0_0, '0']
- [blocks_complex_to_mag_squared_1_0, '0', blocks_nlog10_ff_1_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_interleave_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_vector_to_stream_2_0_0_1_0_0, '0']
- [blocks_nlog10_ff_1_0, '0', epy_block_1, '0']
- [blocks_nlog10_ff_1_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0_0, '0', dnn_dnn_onnx_sync_0_0, '0']
- [blocks_stream_to_vector_1_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']
- [blocks_vector_to_stream_1_0_0, '0', blocks_interleave_0_0, '1']
- [blocks_vector_to_stream_1_1, '0', blocks_interleave_0_0, '0']
- [blocks_vector_to_stream_2_0_0_1_0_0_0, '0', qtgui_time_raster_sink_x_0_0_0_0_1_0_0_0, '0']
- [dnn_dnn_onnx_sync_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [dnn_dnn_onnx_sync_0_0, '0', blocks_vector_to_stream_2_0_0_1_0_0_0, '0']
- [epy_block_0_0_0, '0', blocks_vector_to_stream_1_0_0, '0']
- [epy_block_0_1, '0', blocks_vector_to_stream_1_1, '0']
- [epy_block_1, '0', probe_avg_energy_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_float_0_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', blocks_stream_to_vector_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
