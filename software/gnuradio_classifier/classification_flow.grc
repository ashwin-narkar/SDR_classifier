options:
  parameters:
    generate_options: qt_gui
    id: classification_flow
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    vlen: '128'
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: complex
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: dnn_dnn_onnx_sync_0
  id: dnn_dnn_onnx_sync
  parameters:
    input_size: '256'
    onnx_batch_size: '1'
    onnx_model_file: /home/ashwin/Documents/Capstone/data/fft_model.onnx
    onnx_runtime_device: GPU
    output_size: '15'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.vlen = vlen

          def work(self, input_items, output_items):
              inp = np.asarray(input_items[0])
              
              # print(len(input_items[0]))
              # print(len(input_items[0][0]))
              # print(inp.shape)
                  # self.firstrun = False
              mean = np.mean(inp)
              std_dev = np.std(inp)

              output_items[0][:] = input_items[0] - mean
              output_items[0][:] = output_items[0] / std_dev
              return len(output_items[0])
    vlen: '128'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, vlen=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Normalizer',   # will show up in GRC
                  in_sig=[(np.float32,vlen)],
                  out_sig=[(np.float32,vlen)]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.firstrun = True
              self.vlen = vlen

          def work(self, input_items, output_items):
              inp = np.asarray(input_items[0])
              
              # print(len(input_items[0]))
              # print(len(input_items[0][0]))
              # print(inp.shape)
                  # self.firstrun = False
              mean = np.mean(inp)
              std_dev = np.std(inp)

              output_items[0][:] = input_items[0] - mean
              output_items[0][:] = output_items[0] / std_dev
              return len(output_items[0])
    vlen: '128'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '128'
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(128)
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 2426.5e6
    decim: '2'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2), samp_rate/(2), 1e5)
    type: ccc
  states: {}

connections:
- [blocks_complex_to_float_0, '0', epy_block_0, '0']
- [blocks_complex_to_float_0, '1', epy_block_0_0, '0']
- [blocks_interleave_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_stream_to_vector_0, '0', dnn_dnn_onnx_sync_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_interleave_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_null_sink_0, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_interleave_0, '1']
- [blocks_vector_to_stream_1_0, '0', blocks_null_sink_2, '0']
- [epy_block_0, '0', blocks_vector_to_stream_1, '0']
- [epy_block_0_0, '0', blocks_vector_to_stream_1_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_stream_to_vector_1, '0']

metadata:
  file_format: 1
