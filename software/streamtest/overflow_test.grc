options:
  parameters:
    author: ashwin
    generate_options: qt_gui
    id: overflow_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '10000'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: 10e6
    center_freq0: 2426.5e6
    dev_addr: ''
    dev_args: num_recv_frames=128
    gain0: '0.75'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_head_0, '0', blocks_null_sink_0, '0']
- [uhd_usrp_source_0_0, '0', blocks_head_0, '0']

metadata:
  file_format: 1
