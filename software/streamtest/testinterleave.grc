options:
  parameters:
    author: ashwin
    generate_options: qt_gui
    id: testinterleave
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '[0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5,0.5]'
    type: float
    vlen: '128'
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    type: float
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_stream_to_vector_2
  id: blocks_stream_to_vector
  parameters:
    num_items: '256'
    type: float
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: '128'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '128'
    x_start: '0'
    x_step: '1.0'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    vlen: '128'
    x_start: '0'
    x_step: '1.0'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_vector_sink_f_2
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    vlen: '256'
    x_start: '0'
    x_step: '1.0'
    ymax: '2'
    ymin: '-2'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_stream_to_vector_1, '0']
- [analog_const_source_x_1, '0', blocks_stream_to_vector_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_add_const_vxx_0, '0', qtgui_vector_sink_f_1, '0']
- [blocks_interleave_0, '0', blocks_stream_to_vector_2, '0']
- [blocks_stream_to_vector_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_stream_to_vector_2, '0', qtgui_vector_sink_f_2, '0']
- [blocks_vector_to_stream_0, '0', blocks_interleave_0, '1']
- [blocks_vector_to_stream_1, '0', blocks_interleave_0, '0']

metadata:
  file_format: 1
